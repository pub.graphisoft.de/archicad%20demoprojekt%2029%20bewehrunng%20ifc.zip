Properties of the parts of a building model (IFC4)

# File
Description: no view
File name: Bewehrung 1.OG.ifc
Time: 2025-11-12T15:32:01
Author: Harald Bogendörfer
Organization: No Organization
Written by: ODA SDAI 25.4
Authorization: hbogendoerfer

# IfcSite, Grundstück
RefLatitude: 48, 8, 10, 320000; RefLongitude: 11, 41, 19, 320000

# IfcBuildingStorey, 1. Obergeschoss
In: Archicad Demoprojekt Bürogebäude
Elevation: 8.8 m

# IfcReinforcingBar (84)
In: 1. Obergeschoss
Material: B500B
AllplanAttributes - Objektname: Rundstahlbewehrung; Position number: 1; Bending diameter: 0; Shape code: AA; Creation flags: 4; Maximal length: 6000; Maximal width: 2300; Longitudinal overlapping: 340; Cross overlapping: 340; Weight of the mesh: 4.11594; Count of bars/meshes: 57; Factor for layers: 1; Factor for components: 1; Factor for pieces: 1; Placing direction: 0; Type of the mesh: 1; Mesh group in catalogue: 0; Abrechnungsart: kg
Allplan_ReinforcingBar - Creation flags: 60; Factor for layers: 1; Factor for components: 1; Factor for pieces: 1
Name | NominalDiameter (m) | CrossSectionArea (m2) | Allright_Bauteil_ID | Position number | Bending diameter | Shape code | Count of bars/meshes | Weight per meter
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 1 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 2 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 3 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 4 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 5 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 6 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 7 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 8 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 9 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 10 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 11 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 12 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 13 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 14 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 15 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 16 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 17 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 18 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 19 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 20 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 21 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 22 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 23 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 24 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 25 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 26 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 27 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 28 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 29 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 30 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 31 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 32 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 33 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 34 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 35 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0134RuB0000000087 | 36 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.014 | 0.000154 | 0134RuB0000000088 | 37 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 38 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 39 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 40 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 41 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 42 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 43 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 44 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 45 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 46 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 47 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 48 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 49 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 50 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 51 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 52 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 53 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 54 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 55 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 56 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 57 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 58 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 59 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 60 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 61 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 62 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 63 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 64 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 65 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 66 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 67 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 68 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 69 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 70 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 71 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 72 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 73 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 74 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 75 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 76 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 77 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 78 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 79 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 80 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 81 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 82 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 83 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0134RuB0000000088 | 84 | 56 | A1 | 1 | 1.21

# IfcReinforcingMesh (83)
In: 1. Obergeschoss
Material: B500A
AllplanAttributes - Objektname: Mattenbewehrung; Abrechnungsart: kg
Name | AllplanAttributes, Position number | AllplanAttributes, Bending diameter = AllplanAttributes, Placing direction = AllplanAttributes, Mesh group in catalogue | AllplanAttributes, Shape code | AllplanAttributes, Creation flags | AllplanAttributes, Maximal length | AllplanAttributes, Maximal width | AllplanAttributes, Longitudinal overlapping = AllplanAttributes, Cross overlapping | AllplanAttributes, Weight of the mesh | AllplanAttributes, Count of bars/meshes | AllplanAttributes, Factor for layers = AllplanAttributes, Factor for components = AllplanAttributes, Factor for pieces = AllplanAttributes, Type of the mesh | Allright_Bauteil_ID | MeshLength (m) | MeshWidth (m) | LongitudinalBarNominalDiameter (m) = TransverseBarNominalDiameter (m) | LongitudinalBarCrossSectionArea (m2) = TransverseBarCrossSectionArea (m2) | LongitudinalBarSpacing (m) = TransverseBarSpacing (m) | Allplan_ReinforcingMesh, Position number | Allplan_ReinforcingMesh, Bending diameter = Allplan_ReinforcingMesh, Placing direction = Allplan_ReinforcingMesh, Mesh group in catalogue | Allplan_ReinforcingMesh, Shape code | Allplan_ReinforcingMesh, Creation flags | Allplan_ReinforcingMesh, Maximal length | Allplan_ReinforcingMesh, Maximal width | Allplan_ReinforcingMesh, Longitudinal overlapping = Allplan_ReinforcingMesh, Cross overlapping | Allplan_ReinforcingMesh, Weight of the mesh | Allplan_ReinforcingMesh, Count of bars/meshes = Allplan_ReinforcingMesh, Factor for layers = Allplan_ReinforcingMesh, Factor for components = Allplan_ReinforcingMesh, Factor for pieces = Allplan_ReinforcingMesh, Type of the mesh
Q257A | 8 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0007Kop0000000193 | AllplanAttributes - Bezeichnung: Q257A; Material: B500A
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0007Kop0000000332 | AllplanAttributes - Bezeichnung: Q257A; Material: B500A
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0007Kop0000000437 | AllplanAttributes - Bezeichnung: Q257A; Material: B500A
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002223 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 1 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002224 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 2 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002225 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 3 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002226 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 4 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002227 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 5 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002228 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 6 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002229 | 3.22 | 2.3 | 0.007 | 0.000257 | 0.15 | 7 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002230 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 8 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002231 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 9 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002232 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 10 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002233 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 11 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002234 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 12 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002235 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 13 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002236 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 14 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002238 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 16 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002239 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 17 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002240 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 18 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002241 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 19 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002242 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 20 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002243 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 21 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002244 | 3.22 | 2.3 | 0.007 | 0.000257 | 0.15 | 22 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002245 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 23 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002246 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 24 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002247 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 25 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002248 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 26 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002249 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 27 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002250 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 28 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002251 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 29 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002253 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 31 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0133MaB0000002254 | 3.45994 | 2.3 | 0.007 | 0.000257 | 0.15 | 32 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 8 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0133MaB0000002256 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 33 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 8 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0133MaB0000002260 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 36 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 8 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0133MaB0000002261 | 3.22 | 2.3 | 0.007 | 0.000257 | 0.15 | 37 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 8 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0133MaB0000002262 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 38 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 8 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0133MaB0000002263 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 39 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 8 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0133MaB0000002265 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 41 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 8 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0133MaB0000002266 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 42 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 8 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0133MaB0000002267 | 4.1 | 2.3 | 0.007 | 0.000257 | 0.15 | 43 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 8 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0133MaB0000002268 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 44 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 8 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0133MaB0000002269 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 45 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002272 | 3.20766 | 2.3 | 0.007 | 0.000257 | 0.15 | 47 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002273 | 3.14234 | 2.3 | 0.007 | 0.000257 | 0.15 | 48 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002274 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 49 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002275 | 3.45994 | 2.3 | 0.007 | 0.000257 | 0.15 | 50 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002276 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 51 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002277 | 3.45994 | 2.3 | 0.007 | 0.000257 | 0.15 | 52 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002278 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 53 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002279 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 54 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002280 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 55 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002282 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 56 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002283 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 57 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002284 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 58 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002286 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 60 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002287 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 61 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002288 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 62 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002289 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 63 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002290 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 64 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002291 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 65 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002292 | 3.22 | 2.3 | 0.007 | 0.000257 | 0.15 | 66 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002293 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 67 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002294 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 68 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002295 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 69 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002296 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 70 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002297 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 71 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002298 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 72 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002299 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 73 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002301 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 75 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002302 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 76 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002303 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 77 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002304 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 78 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002305 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 79 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002306 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 80 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002307 | 3.22 | 2.3 | 0.007 | 0.000257 | 0.15 | 81 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002308 | 3 | 1.42 | 0.007 | 0.000257 | 0.15 | 82 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002309 | 6 | 1.42 | 0.007 | 0.000257 | 0.15 | 83 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002310 | 6 | 1.42 | 0.007 | 0.000257 | 0.15 | 84 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002311 | 6 | 1.42 | 0.007 | 0.000257 | 0.15 | 85 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002312 | 6 | 1.42 | 0.007 | 0.000257 | 0.15 | 86 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002313 | 6 | 1.42 | 0.007 | 0.000257 | 0.15 | 87 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0133MaB0000002314 | 6 | 1.42 | 0.007 | 0.000257 | 0.15 | 88 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
