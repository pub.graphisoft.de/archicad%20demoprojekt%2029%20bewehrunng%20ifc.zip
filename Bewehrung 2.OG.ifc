Properties of the parts of a building model (IFC4)

# File
Description: no view
File name: Bewehrung 2.OG.ifc
Time: 2025-11-12T15:32:46
Author: Harald Bogendörfer
Organization: No Organization
Written by: ODA SDAI 25.4
Authorization: hbogendoerfer

# IfcSite, Grundstück
RefLatitude: 48, 8, 10, 320000; RefLongitude: 11, 41, 19, 320000

# IfcBuildingStorey, 2. Obergeschoss
In: Archicad Demoprojekt Bürogebäude
Elevation: 4.4 m

# IfcReinforcingBar (84)
In: 2. Obergeschoss
Material: B500B
AllplanAttributes - Objektname: Rundstahlbewehrung; Position number: 1; Bending diameter: 0; Shape code: AA; Creation flags: 4; Maximal length: 6000; Maximal width: 2300; Longitudinal overlapping: 340; Cross overlapping: 340; Weight of the mesh: 4.11594; Count of bars/meshes: 57; Factor for layers: 1; Factor for components: 1; Factor for pieces: 1; Placing direction: 0; Type of the mesh: 1; Mesh group in catalogue: 0; Abrechnungsart: kg
Allplan_ReinforcingBar - Creation flags: 60; Factor for layers: 1; Factor for components: 1; Factor for pieces: 1
Name | NominalDiameter (m) | CrossSectionArea (m2) | Allright_Bauteil_ID | Position number | Bending diameter | Shape code | Count of bars/meshes | Weight per meter
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 1 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 2 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 3 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.014 | 0.000154 | 0154RuB0000000242 | 4 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 5 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 6 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 7 | 56 | A1 | 1 | 1.21
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 8 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 9 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 10 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.014 | 0.000154 | 0154RuB0000000242 | 11 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 12 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 13 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 14 | 56 | A1 | 1 | 1.21
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 15 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 16 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 17 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.014 | 0.000154 | 0154RuB0000000242 | 18 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 19 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 20 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 21 | 56 | A1 | 1 | 1.21
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 22 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 23 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 24 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.014 | 0.000154 | 0154RuB0000000242 | 25 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 26 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 27 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 28 | 56 | A1 | 1 | 1.21
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 29 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 30 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 31 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.014 | 0.000154 | 0154RuB0000000242 | 32 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 33 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 34 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 35 | 56 | A1 | 1 | 1.21
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 36 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 37 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 38 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.014 | 0.000154 | 0154RuB0000000242 | 39 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 40 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 41 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 42 | 56 | A1 | 1 | 1.21
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 43 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 44 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 45 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.014 | 0.000154 | 0154RuB0000000242 | 46 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 47 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 48 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 49 | 56 | A1 | 1 | 1.21
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 50 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 51 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 52 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.014 | 0.000154 | 0154RuB0000000242 | 53 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 54 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 55 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 56 | 56 | A1 | 1 | 1.21
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 57 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 58 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 59 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.014 | 0.000154 | 0154RuB0000000242 | 60 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 61 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 62 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 63 | 56 | A1 | 1 | 1.21
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 64 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 65 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 66 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.014 | 0.000154 | 0154RuB0000000242 | 67 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 68 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 69 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 70 | 56 | A1 | 1 | 1.21
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 71 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 72 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 73 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.014 | 0.000154 | 0154RuB0000000242 | 74 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 75 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 76 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 77 | 56 | A1 | 1 | 1.21
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 78 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 79 | 32 | B1 | 6 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.008 | 0.0000503 | 0154RuB0000000241 | 80 | 32 | B1 | 22 | 0.395 | Allplan_ReinforcingBar - Hook angle - begin: 135; Hook length - begin: 110; Hook bending diameter - begin: 32; Hook angle - end: 135; Hook length - end: 110; Hook bending diameter - end: 32
 | 0.014 | 0.000154 | 0154RuB0000000242 | 81 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 82 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 83 | 56 | A1 | 1 | 1.21
 | 0.014 | 0.000154 | 0154RuB0000000242 | 84 | 56 | A1 | 1 | 1.21

# IfcReinforcingMesh (83)
In: 2. Obergeschoss
Material: B500A
AllplanAttributes - Objektname: Mattenbewehrung; Abrechnungsart: kg
Name | AllplanAttributes, Position number | AllplanAttributes, Bending diameter = AllplanAttributes, Placing direction = AllplanAttributes, Mesh group in catalogue | AllplanAttributes, Shape code | AllplanAttributes, Creation flags | AllplanAttributes, Maximal length | AllplanAttributes, Maximal width | AllplanAttributes, Longitudinal overlapping = AllplanAttributes, Cross overlapping | AllplanAttributes, Weight of the mesh | AllplanAttributes, Count of bars/meshes | AllplanAttributes, Factor for layers = AllplanAttributes, Factor for components = AllplanAttributes, Factor for pieces = AllplanAttributes, Type of the mesh | Allright_Bauteil_ID | MeshLength (m) | MeshWidth (m) | LongitudinalBarNominalDiameter (m) = TransverseBarNominalDiameter (m) | LongitudinalBarCrossSectionArea (m2) = TransverseBarCrossSectionArea (m2) | LongitudinalBarSpacing (m) = TransverseBarSpacing (m) | Allplan_ReinforcingMesh, Position number | Allplan_ReinforcingMesh, Bending diameter = Allplan_ReinforcingMesh, Placing direction = Allplan_ReinforcingMesh, Mesh group in catalogue | Allplan_ReinforcingMesh, Shape code | Allplan_ReinforcingMesh, Creation flags | Allplan_ReinforcingMesh, Maximal length | Allplan_ReinforcingMesh, Maximal width | Allplan_ReinforcingMesh, Longitudinal overlapping = Allplan_ReinforcingMesh, Cross overlapping | Allplan_ReinforcingMesh, Weight of the mesh | Allplan_ReinforcingMesh, Count of bars/meshes = Allplan_ReinforcingMesh, Factor for layers = Allplan_ReinforcingMesh, Factor for components = Allplan_ReinforcingMesh, Factor for pieces = Allplan_ReinforcingMesh, Type of the mesh
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0008Kop0000000193 | AllplanAttributes - Bezeichnung: Q257A; Material: B500A
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0008Kop0000000352 | AllplanAttributes - Bezeichnung: Q257A; Material: B500A
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0008Kop0000000437 | AllplanAttributes - Bezeichnung: Q257A; Material: B500A
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011820 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 1 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011821 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 2 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011822 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 3 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011823 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 4 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011824 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 5 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011825 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 6 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011826 | 3.22 | 2.3 | 0.007 | 0.000257 | 0.15 | 7 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011827 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 8 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011828 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 9 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011829 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 10 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011830 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 11 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011831 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 12 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011832 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 13 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011833 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 14 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011835 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 16 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011836 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 17 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011837 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 18 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011838 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 19 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011839 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 20 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011840 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 21 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011841 | 3.22 | 2.3 | 0.007 | 0.000257 | 0.15 | 22 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011842 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 23 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011843 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 24 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011844 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 25 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011845 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 26 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011846 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 27 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011847 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 28 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011848 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 29 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011850 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 31 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A |  |  |  |  |  |  |  |  |  |  | 0153MaB0000011851 | 3.45994 | 2.3 | 0.007 | 0.000257 | 0.15 | 32 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011853 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 33 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011856 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 36 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011857 | 3.22 | 2.3 | 0.007 | 0.000257 | 0.15 | 37 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011858 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 38 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011859 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 39 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011860 | 4.1 | 2.3 | 0.007 | 0.000257 | 0.15 | 40 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011861 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 41 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011862 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 42 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011864 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 44 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011865 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 45 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011867 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 47 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011868 | 3.56 | 2.3 | 0.007 | 0.000257 | 0.15 | 48 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011869 | 3.14234 | 2.3 | 0.007 | 0.000257 | 0.15 | 49 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011870 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 50 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 9 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 1 | 1 | 0153MaB0000011871 | 3.45994 | 2.3 | 0.007 | 0.000257 | 0.15 | 51 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011873 | 3.20766 | 2.3 | 0.007 | 0.000257 | 0.15 | 52 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011874 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 53 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011875 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 54 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011876 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 55 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011878 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 56 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011879 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 57 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011880 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 58 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011882 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 60 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011883 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 61 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011884 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 62 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011885 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 63 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011886 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 64 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011887 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 65 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011888 | 3.22 | 2.3 | 0.007 | 0.000257 | 0.15 | 66 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011889 | 3 | 2.3 | 0.007 | 0.000257 | 0.15 | 67 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011890 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 68 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011891 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 69 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011892 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 70 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011893 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 71 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011894 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 72 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011895 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 73 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011897 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 75 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011898 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 76 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011899 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 77 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011900 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 78 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011901 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 79 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011902 | 6 | 2.3 | 0.007 | 0.000257 | 0.15 | 80 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011903 | 3.22 | 2.3 | 0.007 | 0.000257 | 0.15 | 81 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011904 | 3 | 1.42 | 0.007 | 0.000257 | 0.15 | 82 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011905 | 6 | 1.42 | 0.007 | 0.000257 | 0.15 | 83 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011906 | 6 | 1.42 | 0.007 | 0.000257 | 0.15 | 84 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011907 | 6 | 1.42 | 0.007 | 0.000257 | 0.15 | 85 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011908 | 6 | 1.42 | 0.007 | 0.000257 | 0.15 | 86 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011909 | 6 | 1.42 | 0.007 | 0.000257 | 0.15 | 87 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
Q257A | 1 | 0 | AA | 4 | 6000 | 2300 | 340 | 4.11594 | 57 | 1 | 0153MaB0000011910 | 6 | 1.42 | 0.007 | 0.000257 | 0.15 | 88 | 0 | A1 | 4 | 6000 | 2300 | 340 | 4.11594 | 1
